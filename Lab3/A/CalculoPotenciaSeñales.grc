options:
  parameters:
    author: Damian_Morales_J1C_G6
    generate_options: qt_gui
    id: CalculoPotenciaSeñales
    output_language: python
    title: CalculoPotenciaSeñales
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    label: Amplitud de la señal
    start: '0'
    step: '1'
    stop: '6'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: Lab3_a_0
  id: Lab3_a
  parameters:
    l_vect: '1024'
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: A
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_sig_source_x_1, '0', Lab3_a_0, '0']
- [analog_sig_source_x_1, '0', qtgui_freq_sink_x_0, '0']
- [analog_sig_source_x_1, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
